# Keil uVision project 485Relay.uvprojx, settings and files
target 485Relay (ARM-ADS)
  device: STM32F373CB STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00006000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 485Relay +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\cmsis\include;..\stdperiph\include;..\user\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group CMSIS
    ../cmsis/source/: startup_stm32f37x.S
  group STDPERIPH
    ../stdperiph/source/: stm32f37x_adc.c stm32f37x_can.c stm32f37x_cec.c stm32f37x_comp.c stm32f37x_crc.c stm32f37x_dac.c stm32f37x_dbgmcu.c stm32f37x_dma.c stm32f37x_exti.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_i2c.c stm32f37x_iwdg.c stm32f37x_misc.c stm32f37x_pwr.c stm32f37x_rcc.c stm32f37x_rtc.c stm32f37x_sdadc.c stm32f37x_spi.c stm32f37x_syscfg.c stm32f37x_tim.c stm32f37x_usart.c stm32f37x_wwdg.c
  group USER
    ../user/source/: DLT645.c Flash.c GPIO.c main.c stm32f37x_it.c system_stm32f37x.c Time.c Uart.c
